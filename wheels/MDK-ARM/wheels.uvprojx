# Keil uVision project wheels.uvprojx, settings and files
target wheels (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: wheels +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F407xx,DEBUG
  c include: ../code/Inc;../code/Middlewares/Third_Party/LwIP/src/include;../code/Middlewares/Third_Party/LwIP/system;../code/Drivers/STM32F4xx_HAL_Driver/Inc;../code/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../code/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../code/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../code/Middlewares/Third_Party/LwIP/src/include/lwip;../code/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../code/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../code/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../code/Middlewares/Third_Party/LwIP/src/include/netif;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../code/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../code/Middlewares/Third_Party/LwIP/src/include/compat/stdc;../code/Middlewares/Third_Party/LwIP/system/arch;../code/Drivers/CMSIS/Include;..\code\Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../code/Src/: main.c gpio.c lwip.c ethernetif.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c debug.c udp_server.c usart_ex.c dma.c ads1278.c ads1220.c
  group Drivers/STM32F4xx_HAL_Driver
    ../code/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_hal_eth.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_spi.c stm32f4xx_ll_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c
  group Drivers/CMSIS
    ../code/Src/: system_stm32f4xx.c
  group Middlewares/LwIP
    ../code/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../code/Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../code/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../code/Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../code/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
